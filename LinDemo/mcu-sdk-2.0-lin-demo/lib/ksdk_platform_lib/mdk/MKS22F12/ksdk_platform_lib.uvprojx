# Keil uVision project ksdk_platform_lib.uvprojx, settings and files
target ksdk_platform_lib Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_platform.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKS22FN256VLL12
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MKS22F12/include;../../../../platform/devices/MKS22F12/startup;../../../../platform/drivers;../../../../platform/drivers/common;../../../../platform/drivers/wdog;../../../../platform/drivers/uart;../../../../platform/drivers/uart;../../../../platform/drivers/tpm;../../../../middleware/sdmmc/include;../../../../middleware/sdmmc/src;../../../../platform/drivers/smc;../../../../platform/drivers/sim;../../../../platform/drivers/sai;../../../../platform/drivers/sai;../../../../platform/drivers/rtc;../../../../platform/drivers/rnga;../../../../platform/drivers/include;../../../../platform/drivers/rcm;../../../../platform/drivers/port;../../../../platform/drivers/pmc;../../../../platform/drivers/pit;../../../../platform/drivers/pdb;../../../../platform/drivers/osc;../../../../platform/drivers/mcg;../../../../platform/drivers/lpuart;../../../../platform/drivers/lpuart;../../../../platform/drivers/lpi2c;../../../../platform/drivers/lpi2c;../../../../platform/drivers/lptmr;../../../../platform/drivers/llwu;../../../../platform/drivers/gpio;../../../../platform/drivers/flexio;../../../../platform/drivers/flexcan;../../../../platform/drivers/flexcan;../../../../platform/flash;../../../../platform/drivers/ewm;../../../../platform/drivers/common;../../../../platform/drivers/edma;../../../../platform/drivers/dspi;../../../../platform/drivers/dspi;../../../../platform/drivers/dmamux;../../../../platform/drivers/dac;../../../../platform/drivers/crc;../../../../platform/drivers/common;../../../../platform/drivers/cmp;../../../../platform/devices/MKS22F12;../../../../platform/drivers/adc16
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group platform-wdog
    ../../../../platform/drivers/wdog/: fsl_wdog.h fsl_wdog.c
  group platform-uart
    ../../../../platform/drivers/uart/: fsl_uart_edma.h fsl_uart_edma.c fsl_uart.h fsl_uart.c
  group platform-tpm
    ../../../../platform/drivers/tpm/: fsl_tpm.c fsl_tpm.h
  group platform-sdspi
    ../../../../middleware/sdmmc/include/: fsl_sdspi.h fsl_specification.h
    ../../../../middleware/sdmmc/src/: fsl_sdspi.c
  group platform-smc
    ../../../../platform/drivers/smc/: fsl_smc.h fsl_smc.c
  group platform-sim
    ../../../../platform/drivers/sim/: fsl_sim.c
  group platform-sai
    ../../../../platform/drivers/sai/: fsl_sai_edma.h fsl_sai_edma.c fsl_sai.h fsl_sai.c
  group platform-rtc
    ../../../../platform/drivers/rtc/: fsl_rtc.c fsl_rtc.h
  group platform-rnga
    ../../../../platform/drivers/rnga/: fsl_rnga.c fsl_rnga.h
  group platform-rcm
    ../../../../platform/drivers/rcm/: fsl_rcm.c fsl_rcm.h
  group platform-port
    ../../../../platform/drivers/port/: fsl_port.h fsl_port.c
  group platform-pmc
    ../../../../platform/drivers/pmc/: fsl_pmc.h fsl_pmc.c
  group platform-pit
    ../../../../platform/drivers/pit/: fsl_pit.c fsl_pit.h
  group platform-pdb
    ../../../../platform/drivers/pdb/: fsl_pdb.c fsl_pdb.h
  group platform-osc
    ../../../../platform/drivers/osc/: fsl_osc.h
  group platform-mcg
    ../../../../platform/drivers/mcg/: fsl_mcg.c
  group platform-lpuart
    ../../../../platform/drivers/lpuart/: fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_lpuart.h fsl_lpuart.c
  group platform-lpi2c
    ../../../../platform/drivers/lpi2c/: fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpi2c.c fsl_lpi2c.h
  group platform-lptmr
    ../../../../platform/drivers/lptmr/: fsl_lptmr.c fsl_lptmr.h
  group platform-llwu
    ../../../../platform/drivers/llwu/: fsl_llwu.h fsl_llwu.c
  group platform-gpio
    ../../../../platform/drivers/gpio/: fsl_gpio.h fsl_gpio.c
  group platform-flexio
    ../../../../platform/drivers/flexio/: fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio.c fsl_flexio.h
  group platform-flexcan
    ../../../../platform/drivers/flexcan/: fsl_flexcan_edma.h fsl_flexcan_edma.c fsl_flexcan.h fsl_flexcan.c
  group platform-flash
    ../../../../platform/flash/: fsl_flash.h SSD_FTFx_internal.c flash_cache_clear.c flash_command_sequence.c flash_erase.c flash_erase_all.c flash_erase_all_execute_only_segments.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_execute_only.c flash_is_protected.c flash_program.c flash_program_once.c flash_program_partition.c flash_program_section.c flash_protection.c flash_read_once.c flash_read_resource.c flash_security_bypass.c flash_set_flexram_function.c flash_swap_control.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_erase_all_execute_only_segments.c flash_verify_program.c
  group platform-ewm
    ../../../../platform/drivers/ewm/: fsl_ewm.c fsl_ewm.h
  group platform-edma
    ../../../../platform/drivers/edma/: fsl_edma.h fsl_edma.c
  group platform-dspi
    ../../../../platform/drivers/dspi/: fsl_dspi_edma.h fsl_dspi_edma.c fsl_dspi.h fsl_dspi.c
  group platform-dmamux
    ../../../../platform/drivers/dmamux/: fsl_dmamux.h fsl_dmamux.c
  group platform-dac
    ../../../../platform/drivers/dac/: fsl_dac.c fsl_dac.h
  group platform-crc
    ../../../../platform/drivers/crc/: fsl_crc.c fsl_crc.h
  group platform-cmp
    ../../../../platform/drivers/cmp/: fsl_cmp.c fsl_cmp.h
  group platform-clock
    ../../../../platform/devices/MKS22F12/: fsl_clock_MKS22F12.h fsl_clock_MKS22F12.c
  group platform-adc16
    ../../../../platform/drivers/adc16/: fsl_adc16.c fsl_adc16.h
target ksdk_platform_lib Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_platform.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKS22FN256VLL12
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
