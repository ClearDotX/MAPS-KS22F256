# IAR project ksdk_platform_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/devices; ../../../../platform/devices/MKS22F12/include; ../../../../platform/devices/MKS22F12/startup; ../../../../platform/drivers; ../../../../platform/drivers/common; ../../../../platform/drivers/wdog; ../../../../platform/drivers/uart; ../../../../platform/drivers/uart; ../../../../platform/drivers/tpm; ../../../../middleware/sdmmc/include; ../../../../middleware/sdmmc/src; ../../../../platform/drivers/smc; ../../../../platform/drivers/sim; ../../../../platform/drivers/sai; ../../../../platform/drivers/sai; ../../../../platform/drivers/rtc; ../../../../platform/drivers/rnga; ../../../../platform/drivers/include; ../../../../platform/drivers/rcm; ../../../../platform/drivers/port; ../../../../platform/drivers/pmc; ../../../../platform/drivers/pit; ../../../../platform/drivers/pdb; ../../../../platform/drivers/osc; ../../../../platform/drivers/mcg; ../../../../platform/drivers/lpuart; ../../../../platform/drivers/lpuart; ../../../../platform/drivers/lpi2c; ../../../../platform/drivers/lpi2c; ../../../../platform/drivers/lptmr; ../../../../platform/drivers/llwu; ../../../../platform/drivers/gpio; ../../../../platform/drivers/flexio; ../../../../platform/drivers/flexcan; ../../../../platform/drivers/flexcan; ../../../../platform/flash; ../../../../platform/drivers/ewm; ../../../../platform/drivers/common; ../../../../platform/drivers/edma; ../../../../platform/drivers/dspi; ../../../../platform/drivers/dspi; ../../../../platform/drivers/dmamux; ../../../../platform/drivers/dac; ../../../../platform/drivers/crc; ../../../../platform/drivers/common; ../../../../platform/drivers/cmp; ../../../../platform/devices/MKS22F12; ../../../../platform/drivers/adc16
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKS22FN256VLL12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group platform/adc16
    ../../../../platform/drivers/adc16/: fsl_adc16.c fsl_adc16.h
  group platform/clock
    ../../../../platform/devices/MKS22F12/: fsl_clock_MKS22F12.c fsl_clock_MKS22F12.h
  group platform/cmp
    ../../../../platform/drivers/cmp/: fsl_cmp.c fsl_cmp.h
  group platform/crc
    ../../../../platform/drivers/crc/: fsl_crc.c fsl_crc.h
  group platform/dac
    ../../../../platform/drivers/dac/: fsl_dac.c fsl_dac.h
  group platform/dmamux
    ../../../../platform/drivers/dmamux/: fsl_dmamux.c fsl_dmamux.h
  group platform/dspi
    ../../../../platform/drivers/dspi/: fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h
  group platform/edma
    ../../../../platform/drivers/edma/: fsl_edma.c fsl_edma.h
  group platform/ewm
    ../../../../platform/drivers/ewm/: fsl_ewm.c fsl_ewm.h
  group platform/flash
    ../../../../platform/flash/: flash_cache_clear.c flash_command_sequence.c flash_erase.c flash_erase_all.c flash_erase_all_execute_only_segments.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_execute_only.c flash_is_protected.c flash_program.c flash_program_once.c flash_program_partition.c flash_program_section.c flash_protection.c flash_read_once.c flash_read_resource.c flash_security_bypass.c flash_set_flexram_function.c flash_swap_control.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_erase_all_execute_only_segments.c flash_verify_program.c fsl_flash.h SSD_FTFx_internal.c
  group platform/flexcan
    ../../../../platform/drivers/flexcan/: fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h
  group platform/flexio
    ../../../../platform/drivers/flexio/: fsl_flexio.c fsl_flexio.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h
  group platform/gpio
    ../../../../platform/drivers/gpio/: fsl_gpio.c fsl_gpio.h
  group platform/llwu
    ../../../../platform/drivers/llwu/: fsl_llwu.c fsl_llwu.h
  group platform/lpi2c
    ../../../../platform/drivers/lpi2c/: fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h
  group platform/lptmr
    ../../../../platform/drivers/lptmr/: fsl_lptmr.c fsl_lptmr.h
  group platform/lpuart
    ../../../../platform/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h
  group platform/mcg
    ../../../../platform/drivers/mcg/: fsl_mcg.c
  group platform/osc
    ../../../../platform/drivers/osc/: fsl_osc.h
  group platform/pdb
    ../../../../platform/drivers/pdb/: fsl_pdb.c fsl_pdb.h
  group platform/pit
    ../../../../platform/drivers/pit/: fsl_pit.c fsl_pit.h
  group platform/pmc
    ../../../../platform/drivers/pmc/: fsl_pmc.c fsl_pmc.h
  group platform/port
    ../../../../platform/drivers/port/: fsl_port.c fsl_port.h
  group platform/rcm
    ../../../../platform/drivers/rcm/: fsl_rcm.c fsl_rcm.h
  group platform/rnga
    ../../../../platform/drivers/rnga/: fsl_rnga.c fsl_rnga.h
  group platform/rtc
    ../../../../platform/drivers/rtc/: fsl_rtc.c fsl_rtc.h
  group platform/sai
    ../../../../platform/drivers/sai/: fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h
  group platform/sdspi
    ../../../../middleware/sdmmc/src/: fsl_sdspi.c
    ../../../../middleware/sdmmc/include/: fsl_sdspi.h fsl_specification.h
  group platform/sim
    ../../../../platform/drivers/sim/: fsl_sim.c
  group platform/smc
    ../../../../platform/drivers/smc/: fsl_smc.c fsl_smc.h
  group platform/tpm
    ../../../../platform/drivers/tpm/: fsl_tpm.c fsl_tpm.h
  group platform/uart
    ../../../../platform/drivers/uart/: fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h
  group platform/wdog
    ../../../../platform/drivers/wdog/: fsl_wdog.c fsl_wdog.h
