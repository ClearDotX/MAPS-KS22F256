# IAR project lin_slave.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12; MAPS_KS22; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKS22F12/include; ../../../../../../platform/devices/MKS22F12/startup; ../../../../../../platform/drivers; ..; ../../../../../../platform/utilities/debug_console; ../../../..; ../../../../../../platform/drivers/uart; ../../../../../../platform/drivers/lpuart; ../../../../../../platform/drivers/common; ../../../../../../platform/drivers/port; ../../../../../../platform/utilities/debug_console; ../../../../../../platform/utilities/misc_utilities; ../../../../../../platform/drivers/gpio; ../../../../../../platform/drivers/smc; ../../../../../../platform/drivers/osc; ../../../../../../platform/drivers/mcg; ../../../../../../platform/drivers/pit; ../../../../../../platform/devices/MKS22F12; ../../../../../../middleware/lin_stack/include; ../../../../../../middleware/lin_stack/lowlevel; ../../../../../src/demo_apps/lin_demo/lin_slave/lin_cfg; ../../../../../src/demo_apps/lin_demo/lin_slave/lin_hw_if; ../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: lin_slave_example.out
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKS22F12/linker/iar/MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKS22FN256VLL12; MAPS_KS22; TOWER
  ICCARM.CCIncludePath2: ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MKS22F12/include; ../../../../../platform/devices/MKS22F12/startup; ../../../../../platform/drivers; ..; ../../../../../platform/utilities/debug_console; ../../..; ../../../../../platform/drivers/uart; ../../../../../platform/drivers/lpuart; ../../../../../platform/drivers/common; ../../../../../platform/drivers/port; ../../../../../platform/utilities/debug_console; ../../../../../platform/utilities/misc_utilities; ../../../../../platform/drivers/gpio; ../../../../../platform/drivers/smc; ../../../../../platform/drivers/osc; ../../../../../platform/drivers/mcg; ../../../../../platform/devices/MKS22F12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MKS22F12/linker/iar/MKS22FN256xxx12_flash.icf
  group board
    ../../: app.h hardware_init.c pin_mux.c pin_mux.h
    ../../../../: board.c board.h clock_config.c clock_config.h
  group middleware/lin_stack
    ../../../../../../middleware/lin_stack/: mainpage.h
  group middleware/lin_stack/coreapi
    ../../../../../../middleware/lin_stack/coreapi/: lin_common_api.c lin_common_proto.c lin_j2602_api.c lin_j2602_proto.c lin_lin21_api.c lin_lin21_proto.c
  group middleware/lin_stack/diagnostic
    ../../../../../../middleware/lin_stack/diagnostic/: lin_diagnostic_service.c
  group middleware/lin_stack/include
    ../../../../../../middleware/lin_stack/include/: lin_common_api.h lin_common_proto.h lin_commontl_api.h lin_commontl_proto.h lin_diagnostic_service.h lin_j2602_api.h lin_j2602_proto.h lin_j2602tl_api.h lin_lin21_api.h lin_lin21_proto.h lin_lin21tl_api.h
  group middleware/lin_stack/lowlevel
    ../../../../../../middleware/lin_stack/lowlevel/: lin.c lin.h
  group middleware/lin_stack/transport
    ../../../../../../middleware/lin_stack/transport/: lin_commontl_api.c lin_commontl_proto.c lin_j2602tl_api.c lin_lin21tl_api.c
  group platform/clock
    ../../../../../../platform/devices/MKS22F12/: fsl_clock_MKS22F12.c fsl_clock_MKS22F12.h
  group platform/gpio
    ../../../../../../platform/drivers/gpio/: fsl_gpio.c fsl_gpio.h
  group platform/lpuart
    ../../../../../../platform/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h
  group platform/mcg
    ../../../../../../platform/drivers/mcg/: fsl_mcg.c fsl_mcg.h
  group platform/pit
    ../../../../../../platform/drivers/pit/: fsl_pit.c fsl_pit.h
  group platform/port
    ../../../../../../platform/drivers/port/: fsl_port.c fsl_port.h
  group platform/smc
    ../../../../../../platform/drivers/smc/: fsl_smc.c fsl_smc.h
  group platform/uart
    ../../../../../../platform/drivers/uart/: fsl_uart.c fsl_uart.h
  group source
    ../../../../../src/demo_apps/lin_demo/lin_slave/: main.c
  group source/lin_cfg
    ../../../../../src/demo_apps/lin_demo/lin_slave/lin_cfg/: lin_cfg.c lin_cfg.h
  group source/lin_hw_if
    ../../../../../src/demo_apps/lin_demo/lin_slave/lin_hw_if/: lin_slave_lld_timesrv.c lin_slave_lld_timesrv.h lin_slave_lld_uart.c lin_slave_lld_uart.h
  group startup
    ../../../../../../platform/devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../../platform/devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group utilities
    ../../../../../../platform/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h
    ../../../../../../platform/utilities/misc_utilities/: fsl_misc_utilities.c fsl_misc_utilities.h
