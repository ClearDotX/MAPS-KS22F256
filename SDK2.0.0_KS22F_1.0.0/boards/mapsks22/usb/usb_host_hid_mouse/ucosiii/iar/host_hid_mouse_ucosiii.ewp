# IAR project host_hid_mouse_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/ucosiii/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKS22F12/drivers; ..; ../../../../../../middleware/usb/config/ucosiii; ../../../../../../rtos/ucosiii/uCOS-III/Source; ../../../../../../rtos/ucosiii/uC-CPU; ../../../../../../rtos/ucosiii/uC-LIB; ../../../../../../devices/MKS22F12/utilities; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../..; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host/class; ../../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_hid_mouse_ucosiii.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NODEBUG; CPU_MKS22FN256VLL12; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII
  ICCARM.CCOptLevel: 3
  group ucosiii
    ../../../../../../rtos/ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../../rtos/ucosiii/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
    ../../../../../../rtos/ucosiii/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../rtos/ucosiii/uC-CPU/: cpu_core.h cpu_core.c
  group startup
    ../../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hid.c usb_host_hid.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_ucosiii.h usb_osa_ucosiii.c
  group sources
    ../: app.c host_mouse.c host_mouse.h usb_host_config.h os_cfg.h cpu_cfg.h os_cfg_app.h
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
