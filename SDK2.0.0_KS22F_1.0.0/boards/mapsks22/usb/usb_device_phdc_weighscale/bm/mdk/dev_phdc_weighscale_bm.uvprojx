# Keil uVision project dev_phdc_weighscale_bm.uvprojx, settings and files
target dev_phdc_weighscale_bm Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: dev_phdc_weighscale_bm.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MKS22FN256VLL12, USB_STACK_BM, MAPS_KS22, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../devices/MKS22F12/drivers;../../../../../../platform/osa/inc;../../../../../../devices/MKS22F12/utilities;../../../../../../CMSIS/Include;../../../../../../devices;..;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../..;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device/class;../../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-phdc
    ../: usb_device_phdc.c usb_device_phdc.h
  group sources-ieee11073_agent
    ../: ieee11073_agent.c ieee11073_agent.h ieee11073_types.h ieee11073_timer.c ieee11073_timer.h
  group sources
    ../: usb_device_descriptor.c usb_device_descriptor.h usb_shim_agent.c usb_shim_agent.h weighscale.c weighscale.h usb_device_config.h
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
target dev_phdc_weighscale_bm Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: dev_phdc_weighscale_bm.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, NODEBUG, CPU_MKS22FN256VLL12, USB_STACK_BM, MAPS_KS22, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
