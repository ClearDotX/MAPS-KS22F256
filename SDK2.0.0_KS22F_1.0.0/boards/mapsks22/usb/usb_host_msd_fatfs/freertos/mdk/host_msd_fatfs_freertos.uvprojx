# Keil uVision project host_msd_fatfs_freertos.uvprojx, settings and files
target host_msd_fatfs_freertos Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: host_msd_fatfs_freertos.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MKS22FN256VLL12, USB_STACK_FREERTOS_HEAP_SIZE=12288, USB_STACK_FREERTOS, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F;../../../../../../rtos/freertos/Source/include;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MKS22F12/drivers;..;../../../../../../middleware/usb/config/freertos;../../../../../../middleware/fatfs/src;../../../../../../middleware/fatfs/src/fsl_usb_disk;../../../../../../rtos/freertos/Source;../../../../../../devices/MKS22F12/utilities;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../..;../../../../../../middleware/usb/host;../../../../../../middleware/usb/host/class;../../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..;../../../../../../middleware/usb/config/freertos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group FreeRTOS_Source:portable
    ../../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group startup
    ../../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb-host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group usb-host-class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group sources
    ../: app.c host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h FreeRTOSConfig.h
    ../../../../../../middleware/fatfs/src/fsl_usb_disk/: fsl_usb_disk.c fsl_usb_disk.h
  group sources-fatfs
    ../../../../../../middleware/fatfs/src/: diskio.c diskio.h ff.c ff.h
    ../../../../../../middleware/fatfs/src/option/: unicode.c
  group FreeRTOS_Source
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target host_msd_fatfs_freertos Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: host_msd_fatfs_freertos.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, NODEBUG, CPU_MKS22FN256VLL12, USB_STACK_FREERTOS_HEAP_SIZE=12288, USB_STACK_FREERTOS, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm include: ..;../../../../../../middleware/usb/config/freertos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
