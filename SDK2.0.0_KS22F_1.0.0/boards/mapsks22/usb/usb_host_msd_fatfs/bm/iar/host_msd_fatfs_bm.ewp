# IAR project host_msd_fatfs_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_BM; MAPS_KS22; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../devices/MKS22F12/drivers; ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../../../../middleware/fatfs/src; ../../../../../../middleware/fatfs/src/fsl_usb_disk; ../../../../../../devices/MKS22F12/utilities; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../..; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host/class; ../../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_msd_fatfs_bm.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NODEBUG; CPU_MKS22FN256VLL12; USB_STACK_BM; MAPS_KS22; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: app.c host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h
    ../../../../../../middleware/fatfs/src/fsl_usb_disk/: fsl_usb_disk.c fsl_usb_disk.h
  group sources/fatfs
    ../../../../../../middleware/fatfs/src/: diskio.c diskio.h ff.c ff.h
    ../../../../../../middleware/fatfs/src/option/: unicode.c
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
