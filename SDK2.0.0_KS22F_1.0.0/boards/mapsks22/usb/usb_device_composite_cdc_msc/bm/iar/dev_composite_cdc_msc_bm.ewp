# IAR project dev_composite_cdc_msc_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_BM; MAPS_KS22; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../devices/MKS22F12/drivers; ../../../../../../platform/osa/inc; ../../../../../../devices/MKS22F12/utilities; ../../../../../../CMSIS/Include; ../../../../../../devices; ..; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../..; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/device/class; ../../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_composite_cdc_msc_bm.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NODEBUG; CPU_MKS22FN256VLL12; USB_STACK_BM; MAPS_KS22; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class/msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: composite.c composite.h disk.c disk.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
