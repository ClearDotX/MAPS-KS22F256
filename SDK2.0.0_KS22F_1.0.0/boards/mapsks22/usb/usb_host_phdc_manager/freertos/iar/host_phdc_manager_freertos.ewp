# IAR project host_phdc_manager_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_FREERTOS_HEAP_SIZE=12288; USB_STACK_FREERTOS; PRINTF_FLOAT_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos/Source/include; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MKS22F12/drivers; ..; ../../../../../../middleware/usb/config/freertos; ../../../../../../rtos/freertos/Source; ../../../../../../devices/MKS22F12/utilities; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../..; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host/class; ../../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../../../../../middleware/usb/config/freertos
  ILINK.IlinkOutputFile: host_phdc_manager_freertos.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NODEBUG; CPU_MKS22FN256VLL12; USB_STACK_FREERTOS_HEAP_SIZE=12288; USB_STACK_FREERTOS; PRINTF_FLOAT_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  group FreeRTOS_Source
    ../../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Source/portable
    ../../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group startup
    ../../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_phdc.c usb_host_phdc.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group sources
    ../: app.c host_phdc_manager.c host_phdc_manager.h ieee11073_nomenclature.h ieee11073_nomenclature.c ieee11073_types.h usb_host_config.h FreeRTOSConfig.h
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
