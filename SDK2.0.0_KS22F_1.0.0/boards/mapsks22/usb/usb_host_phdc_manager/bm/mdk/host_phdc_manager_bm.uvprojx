# Keil uVision project host_phdc_manager_bm.uvprojx, settings and files
target host_phdc_manager_bm Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: host_phdc_manager_bm.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MKS22FN256VLL12, USB_STACK_BM, PRINTF_FLOAT_ENABLE, MAPS_KS22, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../devices/MKS22F12/drivers;../../../../../../CMSIS/Include;../../../../../../devices;..;../../../../../../devices/MKS22F12/utilities;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../..;../../../../../../middleware/usb/host;../../../../../../middleware/usb/host/class;../../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group usb-host
    ../../../../../../middleware/usb/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group platform
    ../../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-host-class
    ../../../../../../middleware/usb/host/class/: usb_host_phdc.c usb_host_phdc.h usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h
  group sources
    ../: app.c host_phdc_manager.c host_phdc_manager.h ieee11073_nomenclature.h ieee11073_nomenclature.c ieee11073_types.h usb_host_config.h
  group utilities
    ../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h
  group board
    ../: clock_config.h clock_config.c board.c board.h pin_mux.c pin_mux.h
target host_phdc_manager_bm Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: host_phdc_manager_bm.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, NODEBUG, CPU_MKS22FN256VLL12, USB_STACK_BM, PRINTF_FLOAT_ENABLE, MAPS_KS22, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
