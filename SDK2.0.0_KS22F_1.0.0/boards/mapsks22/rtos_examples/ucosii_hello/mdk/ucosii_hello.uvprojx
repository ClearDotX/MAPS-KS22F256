# Keil uVision project ucosii_hello.uvprojx, settings and files
target ucosii_hello Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: ucosii_hello.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKS22FN256VLL12, FSL_RTOS_UCOSII, MAPS_KS22, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/ucosii/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../rtos/ucosii/uC-CPU/ARM-Cortex-M4/RealView;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKS22F12/drivers;..;../../../../../devices/MKS22F12/utilities;../../../../../rtos/ucosii/uCOS-II/Source;../../../../../rtos/ucosii/uC-CPU;../../../../../rtos/ucosii/uC-LIB;../../..;../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group ucosii
    ../../../../../rtos/ucosii/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c fsl_isr_wrapper.S
    ../../../../../rtos/ucosii/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group source
    ../: os_cfg.h app_hooks.c app_cfg.h cpu_cfg.h ucosii_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
target ucosii_hello Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: ucosii_hello.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NODEBUG, CPU_MKS22FN256VLL12, FSL_RTOS_UCOSII, MAPS_KS22, TOWER
  c misc: as above
  c include: as above
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
