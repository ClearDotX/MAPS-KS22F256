# IAR project ucosii_hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12; FSL_RTOS_UCOSII; MAPS_KS22; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/ucosii/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../rtos/ucosii/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKS22F12/drivers; ..; ../../../../../devices/MKS22F12/utilities; ../../../../../rtos/ucosii/uCOS-II/Source; ../../../../../rtos/ucosii/uC-CPU; ../../../../../rtos/ucosii/uC-LIB; ../../..; ../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: ucosii_hello.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NODEBUG; CPU_MKS22FN256VLL12; FSL_RTOS_UCOSII; MAPS_KS22; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group ucosii
    ../../../../../rtos/ucosii/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c fsl_isr_wrapper.S
    ../../../../../rtos/ucosii/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group source
    ../: os_cfg.h app_hooks.c app_cfg.h cpu_cfg.h ucosii_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
