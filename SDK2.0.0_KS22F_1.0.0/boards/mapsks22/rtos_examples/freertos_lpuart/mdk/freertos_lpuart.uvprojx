# Keil uVision project freertos_lpuart.uvprojx, settings and files
target freertos_lpuart Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: freertos_lpuart.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKS22FN256VLL12, FSL_RTOS_FREE_RTOS, MAPS_KS22, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F;../../../../../rtos/freertos/Source/include;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKS22F12/drivers;../../freertos_uart;..;../../../../../devices/MKS22F12/utilities;../../../../../rtos/freertos/Source;../../..;../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group FreeRTOS_Source:portable
    ../../../../../rtos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group platform-freertos
    ../../../../../devices/MKS22F12/drivers/: fsl_lpuart_freertos.h fsl_lpuart_freertos.c
  group source
    ../: FreeRTOSConfig.h freertos_lpuart.c
  group board-board
    ../: pin_mux.c pin_mux.h
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
  group FreeRTOS_Source
    ../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
target freertos_lpuart Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: freertos_lpuart.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NODEBUG, CPU_MKS22FN256VLL12, FSL_RTOS_FREE_RTOS, MAPS_KS22, TOWER
  c misc: as above
  c include: as above
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
