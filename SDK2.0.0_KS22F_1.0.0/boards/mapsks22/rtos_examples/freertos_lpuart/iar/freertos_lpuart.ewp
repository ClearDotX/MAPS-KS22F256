# IAR project freertos_lpuart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12; FSL_RTOS_FREE_RTOS; MAPS_KS22; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKS22F12/drivers; ../../freertos_uart; ..; ../../../../../devices/MKS22F12/utilities; ../../../../../rtos/freertos/Source; ../../..; ../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_lpuart.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NODEBUG; CPU_MKS22FN256VLL12; FSL_RTOS_FREE_RTOS; MAPS_KS22; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group FreeRTOS_Source
    ../../../../../rtos/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../rtos/freertos/Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Source/portable
    ../../../../../rtos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group platform/freertos
    ../../../../../devices/MKS22F12/drivers/: fsl_lpuart_freertos.h fsl_lpuart_freertos.c
  group source
    ../: FreeRTOSConfig.h freertos_lpuart.c
  group board
    ../: board.c board.h clock_config.c clock_config.h
  group board/board
    ../: pin_mux.c pin_mux.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
