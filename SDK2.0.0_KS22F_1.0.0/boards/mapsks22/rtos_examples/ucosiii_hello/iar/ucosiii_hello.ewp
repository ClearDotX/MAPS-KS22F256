# IAR project ucosiii_hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12; FSL_RTOS_UCOSIII; MAPS_KS22; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../rtos/ucosiii/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKS22F12/drivers; ..; ../../../../../devices/MKS22F12/utilities; ../../../../../rtos/ucosiii/uCOS-III/Source; ../../../../../rtos/ucosiii/uC-CPU; ../../../../../rtos/ucosiii/uC-LIB; ../../..; ../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: ucosiii_hello.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NODEBUG; CPU_MKS22FN256VLL12; FSL_RTOS_UCOSIII; MAPS_KS22; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group ucosiii
    ../../../../../rtos/ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../rtos/ucosiii/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
    ../../../../../rtos/ucosiii/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../rtos/ucosiii/uC-CPU/: cpu_core.h cpu_core.c
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group source
    ../: app_cfg.h os_cfg_app.h os_cfg.h cpu_cfg.h os_app_hooks.h os_app_hooks.c ucosiii_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
