# Keil uVision project ucosiii_hello.uvprojx, settings and files
target ucosiii_hello Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: ucosiii_hello.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKS22FN256VLL12, FSL_RTOS_UCOSIII, MAPS_KS22, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/ARM;../../../../../rtos/ucosiii/uC-CPU/ARM-Cortex-M4/RealView;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKS22F12/drivers;..;../../../../../devices/MKS22F12/utilities;../../../../../rtos/ucosiii/uCOS-III/Source;../../../../../rtos/ucosiii/uC-CPU;../../../../../rtos/ucosiii/uC-LIB;../../..;../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group ucosiii
    ../../../../../rtos/ucosiii/uCOS-III/Ports/ARM-Cortex-M4/Generic/ARM/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../rtos/ucosiii/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../../../../../rtos/ucosiii/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../rtos/ucosiii/uC-CPU/: cpu_core.h cpu_core.c
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_mcg.h fsl_mcg.c fsl_osc.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group source
    ../: app_cfg.h os_cfg_app.h os_cfg.h cpu_cfg.h os_app_hooks.h os_app_hooks.c ucosiii_hello.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
target ucosiii_hello Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: ucosiii_hello.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NODEBUG, CPU_MKS22FN256VLL12, FSL_RTOS_UCOSIII, MAPS_KS22, TOWER
  c misc: as above
  c include: as above
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
