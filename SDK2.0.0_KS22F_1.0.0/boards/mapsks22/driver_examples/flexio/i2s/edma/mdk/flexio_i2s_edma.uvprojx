# Keil uVision project flexio_i2s_edma.uvprojx, settings and files
target flexio_i2s_edma Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: flexio_i2s_edma_example.out +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKS22FN256VLL12, MAPS_KS22, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MKS22F12/drivers;../..;../../../../../../../devices/MKS22F12/utilities;../../../../..;../../../../../../../devices/MKS22F12
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../devices/MKS22F12/arm/: startup_MKS22F12.s
    ../../../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group doc
    ../: readme.txt
  group platform
    ../../../../../../../devices/MKS22F12/drivers/: fsl_sai.h fsl_sai.c fsl_lpi2c.c fsl_lpi2c.h fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_flexio.c fsl_flexio.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_smc.h fsl_smc.c fsl_osc.h fsl_mcg.h fsl_mcg.c
    ../../../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group codec
    ../: fsl_wm8960.h fsl_wm8960.c
  group source
    ../: flexio_i2s_edma.c
    ../../: music.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
target flexio_i2s_edma Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: flexio_i2s_edma_example.out +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NODEBUG, CPU_MKS22FN256VLL12, MAPS_KS22, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
