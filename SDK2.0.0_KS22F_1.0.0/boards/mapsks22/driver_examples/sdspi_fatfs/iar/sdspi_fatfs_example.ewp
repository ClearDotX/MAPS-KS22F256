# IAR project sdspi_fatfs_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12; MAPS_KS22; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKS22F12/drivers; ../../../../../middleware/fatfs/src; ../../../../../middleware/fatfs/src/fsl_sdspi_disk; ..; ../../../../../devices/MKS22F12/utilities; ../../..; ../../../../../middleware/sdmmc/include; ../../../../../middleware/sdmmc/src; ../../../../../devices/MKS22F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sdspi_fatfs_example.out
  ILINK.IlinkIcfFile: MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NODEBUG; CPU_MKS22FN256VLL12; MAPS_KS22; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../../../../../devices/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
  group doc
    ../: readme.txt
  group platform
    ../../../../../devices/MKS22F12/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c fsl_smc.h fsl_smc.c fsl_osc.h fsl_mcg.h fsl_mcg.c
    ../../../../../middleware/sdmmc/include/: fsl_sdspi.h fsl_specification.h
    ../../../../../middleware/sdmmc/src/: fsl_sdspi.c
    ../../../../../devices/MKS22F12/: fsl_clock.h fsl_clock.c
  group source
    ../: sdspi_fatfs.c ffconf.h
  group FATFS_Source
    ../../../../../middleware/fatfs/src/fsl_sdspi_disk/: fsl_sdspi_disk.c fsl_sdspi_disk.h
    ../../../../../middleware/fatfs/src/: integer.h ff.c ff.h diskio.c diskio.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKS22F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h
