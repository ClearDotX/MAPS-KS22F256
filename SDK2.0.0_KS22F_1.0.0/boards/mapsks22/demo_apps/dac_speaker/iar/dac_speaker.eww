<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>dac_speaker</project><configuration>Release</configuration></member><member><project>dac_speaker</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>dac_speaker</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>dac_speaker</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/dac_speaker.ewp</path></project></workspace>
