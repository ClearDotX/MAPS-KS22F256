# IAR project flexio_i2s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKS22FN256VLL12; CLOCK_SETUP=5; IAR; MAPS_KS22; MAPS
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform; ../../../../../platform/utilities/inc; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices/MKS22F25612/include; ../../../../../platform/hal/inc; ../../../../../platform/devices; ../../../../../platform/devices/MKS22F25612/startup; ../../../../../platform/devices/MKS22F25612/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: flexio_i2s.srec
  ILINK.IlinkOutputFile: flexio_i2s.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: ../../../../../platform\devices\MKS22F25612\linker\iar\MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PKE18F512xxx15 Freescale PKE18F512xxx15
  ICCARM.CCDefines: DEBUG; CPU_MKE18F512VLL15; CLOCK_SETUP=0
  ICCARM.CCIncludePath2: ../../../mcu-sdk/platform; ../../../mcu-sdk/platform/utilities/inc; ../../../mcu-sdk/platform/hal/inc; ../../../mcu-sdk/platform/drivers/inc; ../../../mcu-sdk/platform/CMSIS/Include; ../../../mcu-sdk/platform/devices/PKE18F15/include; ../../../mcu-sdk/platform/hal/inc; ../../../mcu-sdk/platform/system/inc; ../../../mcu-sdk/platform/osa/inc; ../../../mcu-sdk/platform/devices; ../../../mcu-sdk/platform/devices/PKE18F15/startup; ../../../mcu-sdk/platform/devices/PKE18F15/include
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: flexio_i2s.bin
  ILINK.IlinkIcfFile: ../../../mcu-sdk/platform\devices\PKE18F15\linker\iar\PKE18F512xxx15_flash.icf
  group (top)
    ../../../../../platform/hal/src/edma/: fsl_edma_hal.c
  group drivers
    ../../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../../platform/hal/src/flexio/: fsl_flexio_hal.c fsl_flexio_i2s_hal.c
    ../../../../../platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../../platform/hal/src/lpi2c/: fsl_lpi2c_hal.c
    ../../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../../platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group source
    ../src/: main.c music.h retarget.c wm8960.c wm8960.h
  group startup
    ../../../../../platform/devices/: startup.c
    ../../../../../platform/devices/MKS22F25612/startup/iar/: startup_MKS22F25612.s
    ../../../../../platform/devices/MKS22F25612/startup/: system_MKS22F25612.c
