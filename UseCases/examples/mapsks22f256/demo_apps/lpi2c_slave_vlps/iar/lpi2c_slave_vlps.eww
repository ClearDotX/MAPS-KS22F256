<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpi2c_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lpi2c_slave_vlps.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lpi2c_slave_vlps</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>lpi2c_slave_vlps</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>lpi2c_slave_vlps</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>lpi2c_slave_vlps</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


