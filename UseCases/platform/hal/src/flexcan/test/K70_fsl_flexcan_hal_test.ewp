# IAR project K70_fsl_flexcan_hal_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK70FN1M0VMJ12
  ICCARM.CCIncludePath2: ..\..\..\..\platform; ..\..\..\..\platform\hal; ..\..\..\..\platform\hal\can; ..\..\..\..\platform\hal\port; ..\..\..\..\platform\startup; ..\..\..\..\platform\startup\MK70F12; ..\..\..\..\platform\startup\MK70F12\iar; ..\..\..\..\platform\drivers; ..\..\..\..\platform\drivers\clock; ..\..\..\..\platform\CMSIS\Include; ..\..\..\..\platform\CMSIS\Include\device; ..\..\..\..\platform\CMSIS\Include\device\MK70F12; ..\..\..\..\platform\utilities; ..\..\..\..\rtos; ..\..\..\..\boards\twrk70f120m; ..\..\..\..\lib\iar\MK70F12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K70_fsl_flexcan_hal_test.srec
  ILINK.IlinkOutputFile: K70_fsl_flexcan_hal_test.out
  ILINK.IlinkIcfFile: ..\..\..\linker\iar\K70F12\K70FN1Mxxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK70FN1M0VMJ12
  ICCARM.CCOptLevel: 3
  group lib/debug
    ../../../../lib/iar/K70F12/output/Debug/: platform_lib.a startup_lib.a
  group lib/Release
    ../../../../lib/iar/K70F12/output/Release/: hal_lib.a platform_lib.a startup_lib.a
  group platform/CMSIS\Include
    ../../../../CMSIS/Include/: core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group platform/CMSIS\Include/device
    ../../../../CMSIS/Include/device/: fsl_device_registers.h
  group platform/CMSIS\Include/device/MK70F12
    ../../../../CMSIS/Include/device/MK70F12/: K70_adc.h K70_cau.h K70_crc.h K70_dma.h K70_dmamux.h K70_flexcan.h K70_fmc.h K70_ftfe.h K70_ftm.h K70_gpio.h K70_i2c.h K70_lcdc.h K70_lptmr.h K70_mcg.h K70_mcm.h K70_osc.h K70_pdb.h K70_pit.h K70_port.h K70_sai.h K70_sdhc.h K70_sim.h K70_smc.h K70_spi.h K70_uart.h K70_usb.h K70_usbhs.h MK70F12.h regs.h system_MK70F12.h
  group platform/hal/can/test/src
    src/: fsl_flexcan_hal_test.c fsl_flexcan_hal_test.h main.c
